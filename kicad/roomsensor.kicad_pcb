# Repository defl/roomsensor

File README.md:

Room Sensor
===========
This is a sensor array suitable for monitoring a room and reporting to KNX. It's 5x4cm which fits ordinary in-wall/ceiling pods. Equipped with the following sensors:

 - CCS811 - CO2 and volatile organic compounds
 - BME280 - Temperature, humidity & pressure
 - MAX44009 - Lux
 - 2x PIR for motion

Uses ~5mA idle and ~25 when the CCS811 chip is heating up, well within the capabilities of the TPUART2's 50mA limit.

Standing on the shoulders of giants
-----------------------------------
This project makes use the following libraries:
 - https://github.com/KONNEKTING/KonnektingDeviceLibrary
 - https://github.com/RobTillaart/Arduino
 - https://github.com/finitespace/BME280
 - https://github.com/sparkfun/CCS811_Air_Quality_Breakout

License Information
-------------------
Please review the LICENSE.md file for license information.
Distributed as-is; no warranty is given.

## KiCad design kicad/roomsensor.kicad_pcb

Board: 2 copper layers, 50.0 x 40.0 mm, 45 parts (7 on the bottom side), 38 nets.

Parts:
C1, C2, C3, C5, C6: 100nF; C_0805
C4: 4.7uF; C_0805
C7, C8: 50nF; C_0805
C9: 1uF; C_0805
C10, C12: 10nF; C_0805
C11: 330u/35V; CP_Radial_D8.0mm_P3.50mm
C13: 10uF; C_0805
C14, C17: 220n; C_0805
C15, C16: 47n/50v; C_1206
D1: LED; LED_1206
D3: US1M (BYG21M orig); D_SMA_Handsoldering
D4: SMAJ43CA; D_SMA_Handsoldering
J1: ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
J2: KNX conn; Wago_243_5.75mm_knx
L1: 220uH; L_10.4x10.4_H4.8
R1, R5, R7: 4.7k; R_0805
R2, R3, R4, R8, R10, R11: 10k; R_0805
R6: 330; R_0805
R9: 68/1w; R_2512
SW1: Signal; SW_SPST_B3U-1000P
SW2: Reset; SW_SPST_B3U-1000P
U1, U4: AS312
U2: CCS811; AMS_LGA-10-1EP_2.7x4mm_Pitch0.6mm
U3: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm
U5: BME280; LGA_3.50_3.50
U6: MAX44009; DFN-6-1EP_2x2mm_Pitch0.65mm
U7: KNXEIBTPUART2; QFN-36-1EP_6x6mm_Pitch0.5mm
Y1: PBRC8.00mr50x000; Crystal_SMD_2012-2pin_2.0x1.2mm
Y2: 4,915MHz; Crystal_SMD_2012-2pin_2.0x1.2mm

Connections:
+3V3: C1.1, C3.1, C4.1, C5.1, C6.1, C9.1, C12.1, C13.1, J1.2, L1.2, R1.1, R4.2, R5.2, R7.2, R8.1, R10.2, SW1.2, U1.1, U2.6, U3.4, U3.6, U3.18, U4.1, U5.2, U5.6, U5.8, U6.1, U7.8, U7.17
/MISO: J1.1, U3.16
/MOSI: J1.4, U3.15
/PC1: U2.3, U3.24
/PC2: U2.7, U3.25
/PC3: U3.26, U6.4
/PD5: R2.2, U3.9
/PD6: R3.2, U3.10
/RST: J1.5, R8.2, SW2.1, U3.29
/RX: U3.30, U7.21
/SCK: J1.3, U3.17
/SCL: R7.1, U2.10, U3.28, U5.4, U6.5
/SDA: R5.1, U2.9, U3.27, U5.3, U6.6
/TX: U3.31, U7.20
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C17.2, D4.2, J1.6, J2.2, R6.1, R11.2, SW2.2, U1.3, U2.1, U2.11, U3.3, U3.5, U3.21, U4.3, U5.1, U5.7, U6.2, U6.3, U7.7, U7.10, U7.16, U7.29, U7.31, U7.32, U7.33, U7.36
unnamed: C2.2, U3.20
unnamed: C7.2, U3.7, Y1.1
unnamed: C8.2, U3.8, Y1.2
unnamed: C10.1, C11.1, C14.2, U7.4, U7.6
unnamed: C14.1, U7.5
unnamed: C15.1, U7.12
unnamed: C15.2, C16.2, D3.1, R9.2, U7.11
unnamed: C16.1, U7.15
unnamed: C17.1, U7.25, U7.28, U7.30, U7.34, U7.35
unnamed: D1.1, R6.2
unnamed: D1.2, U3.23
unnamed: D3.2, D4.1, J2.1
unnamed: L1.1, U7.9
unnamed: R1.2, U2.2
unnamed: R2.1, U1.2
unnamed: R3.1, U4.2
unnamed: R4.1, U5.5
unnamed: R9.1, U7.13
unnamed: R10.1, U7.18
unnamed: R11.1, SW1.1, U3.32
unnamed: U2.4, U2.5
unnamed: U7.23, Y2.1
unnamed: U7.24, Y2.2

## Code that names these connections

File arduino/roomsensor_tester/roomsensor_tester.ino (part):

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
// See KiCad schematic
static const byte PIN_LED = A0;  // PC0, output
static const byte PIN_CCS811_INTERRUPT = A1;  // PC1,PCINT9 input
static const byte PIN_CCS811_WAKE = A2;  // PC2, output
static const byte PIN_MAX44009_INTERRUPT = A3;  // PC3,PCINT11 input
static const byte PIN_SW1 = 2;  // PD2,PCINT18 input; Konnecting KNX programming button, must be on "external input" (PD2, PD3)
static const byte PIN_AS312_1_MOTION = 5;  // PD5,PCINT21 input
static const byte PIN_AS312_2_MOTION = 6;  // PD6,PCINT22 input

// I2C addresses, some depend on physical connections
static const byte I2C_CCS811 = 0x5A;
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
## Commit log

2017-11-09 Import project files
2017-11-10 Fixes for kdevice file, now has proper limits and defaults Roomsensor now reports values for all sensors (some debug still enabled, not yet fully checked)
2017-11-10 More files in .gitignore Updated license and readme Roomsensor now designed to not go in ultra low power sleep mode, incl led ~5ma while running hot. Interrupts still used. Shutting down CCS811 logic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
2017-11-11 Added tester arduino program for debugging
2017-11-11 Arduino - Removed never-will-be-used max thresholds for lux and pressure - Added cyclical retransmission option - Using only one interrupt port - Restructured a bit for always-hot-loop (5mA) - Timer1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
2017-11-11 Cleanups
2017-11-11 Small reordering of vars
2017-11-11 Added 10 second compiled in MAX44009 poll loop Fix for MAX440009 sensor readings
    Newline in README.md

Notices in the files:
arduino/roomsensor_tester/roomsensor_tester.ino:
MIT Licensed, (c) 2017 Dennis Fleurbaaij <mail@dennisfleurbaaij.com>
